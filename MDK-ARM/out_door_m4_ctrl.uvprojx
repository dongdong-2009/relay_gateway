# Keil uVision project out_door_m4_ctrl.uvprojx, settings and files
target out_door_m4_ctrl (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: out_door_m4_ctrl
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Include;       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ../Middlewares/Third_Party/LwIP/src/include;      ../Middlewares/Third_Party/LwIP/system;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Middlewares/Third_Party/LwIP/src/include/lwip;      ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;      ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;      ../Middlewares/Third_Party/LwIP/src/include/netif;      ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;      ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;      ../Middlewares/Third_Party/LwIP/src/include/posix;      ../Middlewares/Third_Party/LwIP/src/include/posix/sys;      ../Middlewares/Third_Party/LwIP/system/arch
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c ethernetif.c usart.c gpio.c stm32f4xx_hal_timebase_TIM.c lwip.c freertos.c tim.c dma.c cJSON.c cpu_.c CRC.c key.c m4_flash.c my_it.c printf_.c relay.c save_data.c socket_lib.c tcm300.c timer_operat.c webserver.c rtc.c uart_recv.c iic.c transmit.c spk.c protocol.c machine_info_cfg.c learn_clear.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md4.c sha1.c md5.c arc4.c des.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c ip6_addr.c icmp6.c nd6.c mld6.c ip6_frag.c inet6.c dhcp6.c ip6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ipcp.c demand.c eap.c mppe.c fsm.c eui64.c chap-md5.c upap.c ipv6cp.c lcp.c multilink.c utils.c auth.c magic.c pppol2tp.c ccp.c chap_ms.c pppcrypt.c pppos.c ecp.c ppp.c vj.c chap-new.c pppoe.c
    ../Middlewares/Third_Party/LwIP/src/core/: raw.c lwip_timers.c tcp.c udp.c tcp_out.c stats.c tcp_in.c init.c netif.c dns.c pbuf.c memp.c def.c inet_chksum.c mem.c sys.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip_frag.c icmp.c autoip.c ip4.c igmp.c dhcp.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_msg.c pppapi.c api_lib.c err.c netdb.c netbuf.c netifapi.c tcpip.c sockets.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c timers.c croutine.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group webpage
    ../Src/WEBPAGES/: login.c outdoor.c
software components: CMSIS:CORE 4.1.0
